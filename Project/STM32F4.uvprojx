# Keil uVision project STM32F4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\User\delay;..\User\beep;..\User\led;..\User\key;..\Libraries\STM32F4_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../User/main/: main.c
    ../User/delay/: delay.c
    ../User/beep/: beep.c
    ../User/led/: led.c
    ../User/key/: key.c
  group CMSIS
    ../Libraries/CMSIS/Source/: system_stm32f4xx.c startup_stm32f401xx.s
  group StdLib
    ../Libraries/STM32F4_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
